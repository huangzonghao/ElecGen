Commit message: load sphere, cylinder, box primitives in loadURDF

File: robots/threewheels.urdf (robot description, URDF)
Before this commit: robot three_wheels, 4 links, 3 joints
Joints:
- joint chassis_wheel_front: parent steer_plate -> chassis
